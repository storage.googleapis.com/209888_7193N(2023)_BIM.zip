Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-26T14:44:41+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: 7193N(2023):7193N-33 Shower system, 7193N(2023):7193N-33 Shower system:498388
In: Level 1
Type - Material: Brass - Matt black
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 33
Type - Dimensions - FaucetNominalDepth: 610.958 mm; FaucetNominalHeight: 1714.62 mm; FaucetNominalWidth: 342.824 mm
Type - General - Author: BIMStone; BIMObjectName: 7193N-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: 1; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 2; VersionDate: 2025/10/01
Type - Green Building Properties - CO2 Emissions (A1-A3): 29.51; CO2 Emissions (A4): 0.77; CO2 Emissions (B7): 1389.6; CO2 Emissions (C2): 0.06; CO2 Emissions (C3): 0.06; CO2 Emissions (C4): 1.62; CO2 Emissions (D): -19.29; EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; LVI Number: 6310906; Noise Class: I (ISO 3822); Noise Class 02ls: I (ISO 3822); NRF Number: 4202575; RSK Number: 8283311; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7193N-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://static.oras.com/EPD/7193N-33; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185434_7193N-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7193N-33
Type - Identity Data - 3D View: https://static.oras.com/3D/7193N-33; Catalog Drawing URL: http://static.oras.com/catdrw/7193N-33; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/7193N-33; FDV Document URL: http://www.oras.com/datasheet/7193N-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7193N-33; Group: Shower system; Installation and Maintenance Guide URL: http://static.oras.com/manual/7193N-33; Interactive AR View URL: https://static.oras.com/AR/7193N-33; Long Marketing: Designed to impress and give an elegant solution for any bathroom. This rainshower system gives you a most comfortable and enjoyable shower experience every day. With focus on high performance while still have and eye on the aesthetics and details to secure an easy installation.The handles are designed to be elegant while still providing a good grip for easy.Our new developed magnectic shelf ”MagShelf” completes the design while covering the connection to the wall.The large and flat head shower has a gentle spray that covers the whole body. Enjoy the even and strong water stream for the ultimate relaxation.Our 3-spray handshower is easy to operate with a nice designed push button to easily change the water sprays.Elegant design and total enjoyment; Manufacturer: Oras; Market: International;Finland;Sweden;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/7193N-33; Model: 7193N-33 Shower system; Name_en: 7193N-33 Shower system; OmniClass Number: 23.45.55.00; Product Code: 7193N-33; Product Family: Oras Optima Style; Product Image URL: http://static.oras.com/image/7193N-33; Product URL: http://static.oras.com/7193N-33; Replacement to: 7193-33; Spare-Part Information URL: http://static.oras.com/sp/7193N-33; Technical DataSheet URL: http://www.oras.com/datasheet/7193N-33/en; Type Name: 7193N-33 Shower system; Usage Group: Sweden; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass - Matt black
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Anti-twist hose connector; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread;Cover plate(s); Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.12 m3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.22 m3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Installation Width: 150 ± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 65 C; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Over Head Shower Size: Ø 250 mm; Shower Parts: Rotatable ball joint connection;Hand shower;Lockable in the middle position;MagShelf. Removable shelf with magnetic attachment;Adjustable shower rail bracket;Swivel overhead shower;Shower hose (1750 mm);Shower rail;Anti limescale technology (easy to clean);Twist guard for shower hose;Variable fixing points; Shower Spray: Normal - Even and soft water stream;Massage - Strong water stream due to rotatable spray nozzles;Rain - Even and strong water stream; Shower Spray Number: 3 spray functions; Spout Projection: 131 mm; Spout Type: Detachable spout; Surface treatment: Matt black; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7193N(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7193N-33; Name: 7193N-33 Shower system; ReplacementCost: n/a; Shape: Sculptured; Size: 345 x 610 x 1715 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Matt black
Type - Pset_ManufacturerTypeInformation - ModelReference: 7193N-33; Manufacturer: Oras
Type - Pset_ProductRequirements - Name: 7193N-33 Shower system; Category: Plumbing Fixtures
Material: <Unnamed>, Brass - Matt black
Pset_DistributionFlowElementCommon - Reference: 7193N-33 Shower system; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 1.84891 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.359164 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7193N(2023); Family and Type: 7193N(2023): 7193N-33 Shower system; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7193N-33 Shower system; Type Id: 498365; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
